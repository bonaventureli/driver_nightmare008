# Keil uVision project app007.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: app007
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\common;..\..\0.0.4\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./common/: app.c buttonsConfig.c ledConfig.c Thread.c spi.c
    ../../0.0.4/src/: common.c delaytime.c mp230_nightmare.c led5604.c led_nightmare.c main.c buttons_nightmare.c
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS:Keil RTX 4.81.0, CMSIS Driver:CAN 1.2, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
